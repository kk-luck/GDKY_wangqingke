# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LG0XX,USE_FULL_ASSERT,MFANG
  c include: ..\..\components\cpulibs\FM33LG0xx_FL_Driver\Inc;..\..\components\cpulibs\CMSIS\Device\FM\FM33xx\Include;..\..\sources\app;..\..\sources\bsp;..\..\sources\bsp\fm33lg0xx;..\..\sources\app\bluetooth;..\..\sources\app\menu;..\..\sources\app\meter;..\..\sources\app\record;..\..\sources;..\..\components\usrlibc;..\..\components\SEGGER_RTT\RTT;..\..\sources\app\radio;..\..\sources\app\lora;..\..\sources\app\record
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../../sources/: main.c
    ../../sources/app/: cmdproc_at.c
  group BSP
    ../../sources/bsp/fm33lg0xx/: sys_tick.c sysClock.c owi.c rs485.c key.c
  group Log
    ../../components/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group usrlibc
    ../../components/usrlibc/: libcheck.c libmisc.c libstdc.c queue.c
  group CMSIS
    ../../components/cpulibs/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
    ../../components/cpulibs/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group StdPeriph_Driver
    ../../components/cpulibs/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_vrefp.c fm33lg0xx_fl_wwdt.c
    ../../sources/bsp/fm33lg0xx/: fm33lg0xx_it.c
  group Doc
    ../../: ChangeLog.txt Directory.txt Download.txt
